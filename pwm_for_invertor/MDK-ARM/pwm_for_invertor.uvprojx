# Keil uVision project pwm_for_invertor.uvprojx, settings and files
target pwm_for_invertor (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pwm_for_invertor
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../../Inc;                                  ../../Drivers/STM32F1xx_HAL_Driver/Inc;                                  ../../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                  ../../Drivers/CMSIS/Include;                                  ../../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
software components: CMSIS:CORE 4.1.0
